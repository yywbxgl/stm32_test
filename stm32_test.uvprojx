# Keil uVision project stm32_test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --gnu -Dlittle_endian
  c include: .\libs;.\libs\inc;.\src;.\src\system;.\src\hardware;.\src\app;.\src\hardware;.\src\USMART;.\test;.\src\app;.\src\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group libs
    ./libs/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./libs/: core_cm3.c startup_stm32f10x_hd.s
  group src
    ./src/app/: fm1702.c main.c mqtt_app.c sim800c.c stm32f10x_it.c system_stm32f10x.c utils.c message.c app.c
    ./src/hardware/: beep.c dcf.c digitron.c exti.c key.c led.c myiic.c rtc.c spi.c timer.c usart3.c wdg.c
    ./src/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ./src/system/: delay.c sys.c usart.c
    ./src/USMART/: usmart.c usmart_config.c usmart_str.c
  group Test
    ./test/: test.c
software components: Data Exchange:JSON:Jansson 2.7.0
